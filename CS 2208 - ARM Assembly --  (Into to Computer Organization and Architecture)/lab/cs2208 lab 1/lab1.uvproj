# Keil uVision project lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: lab1
  c flags: Optim=1
  group Source Group 1
    ./: example1.s
